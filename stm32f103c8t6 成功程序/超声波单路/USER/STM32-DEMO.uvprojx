# Keil uVision project STM32-DEMO.uvprojx, settings and files
target ADC-DEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c usart1.c led.c Time_test.c exti.c ultrasonic.c timer3.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_rtc.c misc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_bkp.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
software components: CMSIS:CORE 4.3.0
