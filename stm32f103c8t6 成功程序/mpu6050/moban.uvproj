# Keil uVision project moban.uvproj, settings and files
target moban (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: moban +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\libraries\inc;.\libraries\src;.\startup;.\user;.\system\delay;.\system\sys;.\system\usart1;.\system\wdg;.\app;.\app\led;.\app\iic;.\app\MPU6050_DMP;.\app\MPU6050
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c stm32f10x_it.c includes.c
  group system
    ./system/delay/: delay.c
    ./system/sys/: sys.c
    ./system/usart1/: usart1.c
    ./system/wdg/: wdg.c
  group app
    ./app/led/: led.c
    ./app/iic/: iic.c
    ./app/MPU6050_DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./app/MPU6050/: mpu6050.c
  group startup
    ./startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group libraries
    ./libraries/src/: stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_iwdg.c stm32f10x_wwdg.c misc.c stm32f10x_dbgmcu.c stm32f10x_tim.c
