# Keil uVision project STM32-DEMO.uvprojx, settings and files
target ADC-DEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\FWlib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\ADC;..\HARDWARE\dht11;..\HARDWARE\DS18B20;..\HARDWARE\GPIO_JTAG;..\HARDWARE\LED;..\HARDWARE\motor;..\HARDWARE\PS2;..\HARDWARE\ultrasonic;..\HARDWARE\Timer;..\HARDWARE\OLED;..\HARDWARE\NRF24L01;..\HARDWARE\SPI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./: main.c
  group FWlib
    ./: stm32f10x_it.c
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_rtc.c misc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_wwdg.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_i2c.c stm32f10x_fsmc.c stm32f10x_dbgmcu.c stm32f10x_dac.c stm32f10x_crc.c stm32f10x_can.c stm32f10x_bkp.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/GPIO_JTAG/: gpio_JTAG.c
    ../HARDWARE/Timer/: timer.c
    ../HARDWARE/OLED/: oled.c bmp.c oledfont.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/dht11/: dht11.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/SPI/: spi.c
software components: CMSIS:CORE 4.3.0
